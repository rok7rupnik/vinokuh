# Repository rok7rupnik/vinokuh

## KiCad design shematika/kiCad/Vinokuh.kicad_pcb

Parts:
C_LCD_1, C_LCD_2: 1uF
C_pow1: 0.33uF
C_pow2: 0.1uF
DCDC1: 7805
DISCOVERY_DESNA1: CONN_20
DSC_L1: CONN_20x2
D_LCD_1, D_LCD_2: DIODESCH
D_REL1, D_REL2: DIODESCH
JUMPER1: CONN_2
MOS_BL1: MOS_Po
OUT_SPODNJA1: CONN 15x2
OUT_Zgoraj1: CONN_15X1
REL1, REL2: MOSFET_N
R_B1, R_B2: 10k
R_BE1: 10k
R_E1, R_E2: 10k
R_GREEN1, R_GREEN2, R_GREEN3, R_GREEN4, R_GREEN5, R_GREEN6, R_GREEN7, R_GREEN8: 180
R_LCD1: 180
R_LCDpu1: 10k
R_RED1, R_RED2, R_RED3, R_RED4, R_RED5, R_RED6, R_RED7, R_RED8: 180
R_T1a1, R_T2a1, R_T3a1, R_T4a1, R_T5a1, R_T6a1, R_T7a1, R_T8a1: 5k
R_T1b1, R_T2b1, R_T3b1, R_T4b1, R_T5b1, R_T6b1, R_T7b1, R_T8b1: 10k

Connections:
/5V: C_pow2.1, DCDC1.VO, DISCOVERY_DESNA1.2, MOS_BL1.S, OUT_SPODNJA1.1, OUT_Zgoraj1.3, R_E1.2, R_E2.2, R_LCDpu1.1
/DB0: DISCOVERY_DESNA1.7, JUMPER1.2 (PM), OUT_SPODNJA1.14, R_B2.1
/DB1: DISCOVERY_DESNA1.9, OUT_SPODNJA1.12, R_B1.1
/DBE: DISCOVERY_DESNA1.8, OUT_SPODNJA1.13, R_BE1.1
/DBL_onoff: DISCOVERY_DESNA1.14, MOS_BL1.G, R_LCDpu1.2
/DBL_pwm: C_LCD_1.2, DISCOVERY_DESNA1.13
/DE1: DISCOVERY_DESNA1.10, OUT_SPODNJA1.11, R_E1.1
/DE2: DISCOVERY_DESNA1.12, OUT_SPODNJA1.10, R_E2.1
/DLg1: DSC_L1.39, R_GREEN1.1
/DLg2: DSC_L1.40, R_GREEN2.1
/DLg3: DSC_L1.37, R_GREEN3.1
/DLg4: DSC_L1.38, R_GREEN4.1
/DLg5: DSC_L1.35, R_GREEN5.1
/DLg6: DSC_L1.36, R_GREEN6.1
/DLg7: DSC_L1.33, R_GREEN7.1
/DLg8: DSC_L1.34, R_GREEN8.1
/DLr1: DSC_L1.31, R_RED1.1
/DLr2: DSC_L1.32, R_RED2.1
/DLr3: DSC_L1.29, R_RED3.1
/DLr4: DSC_L1.30, R_RED4.1
/DLr5: DSC_L1.27, R_RED5.1
/DLr6: DSC_L1.28, R_RED6.1
/DLr7: DSC_L1.25, R_RED7.1
/DLr8: DSC_L1.26, R_RED8.1
/DR1: DISCOVERY_DESNA1.5, REL1.G
/DR2: DISCOVERY_DESNA1.6, REL2.G
/DT1: DSC_L1.10, R_T1a1.2, R_T1b1.1
/DT2: DSC_L1.12, R_T2a1.2, R_T2b1.1
/DT3: DSC_L1.14, R_T3a1.2, R_T3b1.1
/DT4: DSC_L1.16, R_T4a1.2, R_T4b1.1
/DT5: DSC_L1.18, R_T5a1.2, R_T5b1.1
/DT6: DSC_L1.20, R_T6a1.2, R_T6b1.1
/DT7: DSC_L1.22, R_T7a1.2, R_T7b1.1
/DT8: DSC_L1.21, R_T8a1.2, R_T8b1.1
/GND: C_LCD_2.2, C_pow1.2, C_pow2.2, DCDC1.GND, DISCOVERY_DESNA1.1, DSC_L1.1, DSC_L1.2, DSC_L1.5, DSC_L1.23, D_REL1.1 (A), D_REL2.1 (A), OUT_SPODNJA1.2, OUT_Zgoraj1.1, OUT_Zgoraj1.6, REL1.S, REL2.S, R_B1.2, R_B2.2, R_BE1.2, R_T1b1.2, R_T2b1.2, R_T3b1.2, R_T4b1.2, R_T5b1.2, R_T6b1.2, R_T7b1.2, R_T8b1.2
/NRST: DSC_L1.6, JUMPER1.1
/U1: OUT_Zgoraj1.15, R_T1a1.1
/U2: OUT_Zgoraj1.14, R_T2a1.1
/U3: OUT_Zgoraj1.13, R_T3a1.1
/U4: OUT_Zgoraj1.12, R_T4a1.1
/U5: OUT_Zgoraj1.11, R_T5a1.1
/U6: OUT_Zgoraj1.10, R_T6a1.1
/U7: OUT_Zgoraj1.9, R_T7a1.1
/U8: OUT_Zgoraj1.8, R_T8a1.1
/U9: DSC_L1.24, OUT_Zgoraj1.7
/U11: D_REL1.2 (K), OUT_Zgoraj1.5, REL1.D
/U12: D_REL2.2 (K), OUT_Zgoraj1.4, REL2.D
/U14: C_pow1.1, DCDC1.VI, OUT_Zgoraj1.2
/V3: DISCOVERY_DESNA1.20, OUT_SPODNJA1.3
/V4: DISCOVERY_DESNA1.19, OUT_SPODNJA1.4
/V5: DISCOVERY_DESNA1.18, OUT_SPODNJA1.5
/V6: DISCOVERY_DESNA1.17, OUT_SPODNJA1.6
/V7: DISCOVERY_DESNA1.16, OUT_SPODNJA1.7
/V8: DISCOVERY_DESNA1.15, OUT_SPODNJA1.8
/V9: OUT_SPODNJA1.9, R_LCD1.2
/V15: OUT_SPODNJA1.15, R_RED8.2
/V16: OUT_SPODNJA1.16, R_RED7.2
/V17: OUT_SPODNJA1.17, R_RED6.2
/V18: OUT_SPODNJA1.18, R_RED5.2
/V19: OUT_SPODNJA1.19, R_RED4.2
/V20: OUT_SPODNJA1.20, R_RED3.2
/V21: OUT_SPODNJA1.21, R_RED2.2
/V22: OUT_SPODNJA1.22, R_RED1.2
/V23: OUT_SPODNJA1.23, R_GREEN8.2
/V24: OUT_SPODNJA1.24, R_GREEN7.2
/V25: OUT_SPODNJA1.25, R_GREEN6.2
/V26: OUT_SPODNJA1.26, R_GREEN5.2
/V27: OUT_SPODNJA1.27, R_GREEN4.2
/V28: OUT_SPODNJA1.28, R_GREEN3.2
/V29: OUT_SPODNJA1.29, R_GREEN2.2
/V30: OUT_SPODNJA1.30, R_GREEN1.2
unnamed: D_LCD_1.1 (A), MOS_BL1.D
unnamed: C_LCD_1.1, D_LCD_1.2 (K), D_LCD_2.1 (A)
unnamed: C_LCD_2.1, D_LCD_2.2 (K), R_LCD1.1

Notes on the sheet:
Knofi
ArrayLEDic
Uporovni delilniki za termistorje
Encoder
Napajanje
Relays
LCD backlight
B15 B13 B11 E15 E13 E11 E09 E07 GND B01 C05 A07 A05 A03 A01 C03 C01 GND VDD GND
D08 B14 B12 B10 E14 E12 E10 E08 B02 B00 C04 A06 A04 A02 A00 C02 C00 RST VDD GND
A14 C10 C12 D01 D03 D05 D07 B04 B06 BOT B08 E00 E02 E04 E06 C14 H00 3V 5V GND
U13 = input power source

Board: 2 copper layers, 66.0 x 81.3 mm, 60 parts (0 on the bottom side), 74 nets.

Other parts of the board:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4: P***; 1pin

## KiCad design shematika/kiCad/old2/Vinokuh.kicad_pcb

Board: 2 copper layers, 53 parts (0 on the bottom side), 7 nets, no tracks yet.

Parts:
30_UP1: Zgornja Letvica; PIN_ARRAY_17X1
C_LCD_1, C_LCD_2: C; SM1206
DCDC1: 7805; TO220-7805
DSC_D1: DISCOVERY DESNA; PIN_ARRAY_20X2
DSC_L1: DISCOVERY LEVA; PIN_ARRAY_20X2
D_LCD_1, D_LCD_2: DIODESCH; D3
D_REL1, D_REL2: DIODESCH; D3
LET_SP1: Spodnja letva1; PIN_ARRAY_17X1
LET_SP2: Spodnja letva2; PIN_ARRAY_17X1
MOS_BL1: BackLight1; IPAKGDS
REL1, REL2: MOSFET_N; IPAKGDS
R_B1, R_B2: R; SM1206
R_BE1: R; SM1206
R_E1, R_E2: R; SM1206
R_GREEN1, R_GREEN2, R_GREEN3, R_GREEN4, R_GREEN5, R_GREEN6, R_GREEN7, R_GREEN8: R; SM1206
R_LCD1: R; SM1206
R_RED1, R_RED2, R_RED3, R_RED4, R_RED5, R_RED6, R_RED7, R_RED8: R; SM1206
R_T1a1, R_T1b1, R_T2a1, R_T2b1, R_T3a1, R_T3b1, R_T4a1, R_T4b1, R_T5a1, R_T5b1, R_T6a1, R_T6b1, R_T7a1, R_T7b1, R_T8a1, R_T8b1: R; SM1206

Connections:
/3V: DSC_D1.5, DSC_D1.6
/5V: 30_UP1.16, DSC_D1.3, DSC_D1.4, D_LCD_1.1, R_E1.2, R_E2.2
/P?: C_LCD_1.2, MOS_BL1.G, REL1.G, REL2.G, R_B1.1, R_B2.1, R_BE1.1, R_E1.1, R_E2.1, R_GREEN1.1, R_GREEN1.2, R_GREEN2.1, R_GREEN2.2, R_GREEN3.1, R_GREEN3.2, R_GREEN4.1, R_GREEN4.2, R_GREEN5.1, R_GREEN5.2, R_GREEN6.1, R_GREEN6.2, R_GREEN7.1, R_GREEN7.2, R_GREEN8.1, R_GREEN8.2, R_RED1.1, R_RED1.2, R_RED2.1, R_RED2.2, R_RED3.1, R_RED3.2, R_RED4.1, R_RED4.2, R_RED5.1, R_RED5.2, R_RED6.1, R_RED6.2, R_RED7.1, R_RED7.2, R_RED8.1, R_RED8.2, R_T1a1.2, R_T1b1.1, R_T2a1.2, R_T2b1.1, R_T3a1.2, R_T3b1.1, R_T4a1.2, R_T4b1.1, R_T5a1.2, R_T5b1.1, R_T6a1.2, R_T6b1.1, R_T7a1.2, R_T7b1.1, R_T8a1.2, R_T8b1.1
/U?: MOS_BL1.D, REL1.D, REL2.D, R_LCD1.2, R_T1a1.1, R_T2a1.1, R_T3a1.1, R_T4a1.1, R_T5a1.1, R_T6a1.1, R_T7a1.1, R_T8a1.1
GND: 30_UP1.17, C_LCD_2.2, DSC_D1.1, DSC_D1.2, DSC_L1.1, DSC_L1.2, DSC_L1.5, DSC_L1.23, MOS_BL1.S, REL1.S, REL2.S, R_B1.2, R_B2.2, R_BE1.2, R_T1b1.2, R_T2b1.2, R_T3b1.2, R_T4b1.2, R_T5b1.2, R_T6b1.2, R_T7b1.2, R_T8b1.2
unnamed: D_LCD_1.2, D_LCD_2.1
unnamed: C_LCD_2.1, D_LCD_2.2, R_LCD1.1

## Commit log

2014-03-28 Popravljeni pini v Lcd initu, project_rok
