# IAR project HD44780.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCIncludePath2: Application; CMSIS; HD44780; scmRTOS; StdPeriphLib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: CMSIS; HD44780; scmRTOS; StdPeriphLib
  OBJCOPY.OOCOutputFile: HD44780.hex
  ILINK.IlinkOutputFile: HD44780.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  group Application
    Application/: main.cpp main.h
  group CMSIS
    CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_cl.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group HD44780
    HD44780/: HD44780.cpp HD44780.h
  group StdPeriphLib
    StdPeriphLib/: misc.c misc.h stm32f10x_conf.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_it.c stm32f10x_it.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_tim.c stm32f10x_tim.h
