# Keil uVision project vinokuh.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: vinokuh
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\inc;.\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f40xx.s main.c gpio.c adc.c switch.c
    ./inc/: stm32f4xx_conf.h system_stm32f4xx.c
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
